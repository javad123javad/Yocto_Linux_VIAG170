inherit externalsrc
EXTERNALSRC = "/home/javad/workspace/YOCTO/poky/myworkspace/sources/rtl-sdr"

# initial_rev: 0847e93e0869feab50fd27c7afeb85d78ca04631
