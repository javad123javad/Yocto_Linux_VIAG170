inherit externalsrc
EXTERNALSRC = "/home/javad/workspace/YOCTO/poky/myworkspace/sources/linrad"

# initial_rev: 3071ec4861a0730036bf6a08b051be8b70277b99
