inherit externalsrc
EXTERNALSRC = "/home/javad/workspace/YOCTO/poky/myworkspace/sources/ppp"
EXTERNALSRC_BUILD = "/home/javad/workspace/YOCTO/poky/myworkspace/sources/ppp"

# initial_rev: 400f902bcc31471d7e2b1c94b549a601f0b57694
