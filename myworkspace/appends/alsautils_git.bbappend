inherit externalsrc
EXTERNALSRC = "/home/javad/workspace/YOCTO/poky/myworkspace/sources/alsautils"

# initial_rev: 2d105e0f18a82783ea69e2dbe9da7aeb7d3c1346
