inherit externalsrc
EXTERNALSRC = "/home/javad/workspace/YOCTO/poky/myworkspace/sources/nano"

# initial_rev: 30e6af7f0c079c6a774481e4e976419495cd31a0
