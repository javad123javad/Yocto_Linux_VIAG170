inherit externalsrc
EXTERNALSRC = "/home/javad/workspace/YOCTO/poky/myworkspace/sources/fuse"

# initial_rev: 27837fafe8cdf0c45072cc63bb36b587a3a2f854
