inherit externalsrc
EXTERNALSRC = "/home/javad/workspace/YOCTO/poky/myworkspace/sources/libmicrohhtpd"

# initial_rev: 532af189276063436c45b10e1be4d9670ff05efc
