inherit externalsrc
EXTERNALSRC = "/home/javad/workspace/YOCTO/poky/myworkspace/sources/exFat"

# initial_rev: 66747e2df0771b23ea30cbef3767f2b72488e914
